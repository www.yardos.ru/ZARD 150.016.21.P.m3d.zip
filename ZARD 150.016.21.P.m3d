# KOMPAS-3D part (ZARD 150.016.21.P.m3d)

Model tree:
1. Булева операция:2
